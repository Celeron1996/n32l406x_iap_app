# Keil uVision project iap_app.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: N32L406RB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iap_app +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\code\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ./code/src/: main.c log.c tamper.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 1.0.0, Device:StdPeriph Drivers:FLASH 1.0.0, Device:StdPeriph Drivers:Framework 1.0.0, Device:StdPeriph Drivers:GPIO 1.0.0, Device:StdPeriph Drivers:RCC 1.0.0, Device:StdPeriph Drivers:USART 1.0.0, Device:System_N32L40x 1.0.0
